# Keil uVision project h7_standard_project.uvprojx, settings and files
target h7_standard_project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h7_standard_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/Utils;../User/Components;../User/BSP;../User/App;../Middlewares/LVGL;../Middlewares/LVGL/src;../Middlewares/LVGL/demos;../Middlewares/wit_c_sdk;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c memorymap.c sdmmc.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL
    ../Middlewares/LVGL/: lv_conf.h lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h lvgl.h lv_version.h lvgl_private.h
  group Middlewares/wit_sdk
    ../Middlewares/wit_c_sdk/: REG.h wit_c_sdk.c wit_c_sdk.h
  group User/Utils
    ../User/Utils/: logger.c logger.h
  group User/Components
    ../User/Components/: led_dev.c led_dev.h lcd_fonts.c lcd_fonts.h lcd_image.c lcd_image.h lcd_spi_154.c lcd_spi_154.h key_dev.c key_dev.h drv_uart_imu.c drv_uart_imu.h
  group User/BSP
    ../User/BSP/: bsp_led.c bsp_led.h bsp_lcd.c bsp_lcd.h bsp_key.c bsp_key.h bsp_jy61p.c bsp_jy61p.h bsp_sd.c bsp_sd.h
  group Uaer/App
    ../User/App/: app_main.c app_main.h task_led.c task_led.h task_lcd.c task_lcd.h task_lvgl.c task_lvgl.h task_key.c task_key.h task_imu.c task_imu.h task_game.c task_game.h input_manager.h task_uart.c task_uart.h
  group LVGL/src
    ../Middlewares/LVGL/src/: lv_init.c
    ../Middlewares/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/LVGL/src/display/: lv_display.c
    ../Middlewares/LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/LVGL/src/tick/: lv_tick.c
    ../Middlewares/LVGL/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/LVGL/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/LVGL/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middlewares/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/LVGL/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/LVGL/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/src/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/src/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/src/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/LVGL/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/LVGL/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/src/widgets/gif/: lv_gif.c
    ../Middlewares/LVGL/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/src/widgets/win/: lv_win.c
    ../Middlewares/LVGL/src/layouts/: lv_layout.c
    ../Middlewares/LVGL/src/themes/: lv_theme.c
    ../Middlewares/LVGL/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Middlewares/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 4.3.0
